FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-makefile-and-dts-mariner-1b.patch"
