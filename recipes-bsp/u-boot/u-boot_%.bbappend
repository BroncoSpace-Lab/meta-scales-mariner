FILESEXTRAPATHS:prepend = "${THISDIR}/u-boot:"
UBOOT_ENV_FILE = "custom-boot.env"

