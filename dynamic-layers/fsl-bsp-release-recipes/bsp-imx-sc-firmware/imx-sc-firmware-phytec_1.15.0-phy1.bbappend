BOARD_TYPE = "phycore-imx8x-1"