IMAGE_INSTALL:append = " screen"

